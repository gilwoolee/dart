Commit message: Add bioloidGP app with bioloid urdf models

File: data/urdf/ground.urdf (robot description, URDF)
Before this commit: robot ground_skeleton, 2 links, 1 joints
Links:
- link ground_link: geometry collision box size=1.0 1.0 0.05; visual box size=1.0 1.0 0.05
