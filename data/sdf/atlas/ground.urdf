Commit message: Merge branch 'upstream/master'

File: data/sdf/atlas/ground.urdf (robot description, URDF)
Before this commit: robot ground_skeleton, 2 links, 1 joints
Links:
- link ground_link: geometry collision box size=25 0.05 25; visual box size=25 0.05 25
